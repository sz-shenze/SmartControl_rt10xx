# Keil uVision project SmartController.uvprojx, settings and files
target SmartController_ram_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: SmartController +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\..\Source\Platform\RT105x\cmsis;..\..\Source\Platform\RT105x\startup;..\..\Source\Platform\RT105x\fsl_lib\inc;..\..\Source\Configuration\inc;..\..\Source\Platform\RT105x\drives\inc;..\..\Source\Application\Tasks\inc;..\..\Source\Hardware\inc;..\..\Source\Middleware\freertos\include;..\..\Source\Middleware\freertos\portable\RVDS\ARM_CM7\r0p1;..\..\Source\Platform\RT105x\system\inc;..\..\Source\Utilities;..\..\Source\Utilities\io;..\..\Source\Utilities\io\swo;..\..\Source\Utilities\log;..\..\Source\Utilities\str
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\..\Source\Platform\RT105x\script\rt1052_ram_scf.scf
  group Hardware
    ../../Source/Hardware/src/: elcdif.c key.c led.c sdram.c tftlcd.c
  group Aplication
    ../../Source/Application/: ApplicationMain.c
    ../../Source/Application/Tasks/src/: ApplicationTaskGui.c
  group Middleware/freertos
    ../../Source/Middleware/freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../Source/Middleware/freertos/portable/MemMang/: heap_4.c
    ../../Source/Middleware/freertos/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Platform/rt105x/fsl_lib
    ../../Source/Platform/RT105x/fsl_lib/src/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_lpuart.c fsl_elcdif.c fsl_semc.c
  group Platform/rt105x/startup
    ../../Source/Platform/RT105x/startup/: startup_MIMXRT1052.s system_MIMXRT1052.c
  group Platform/rt105x/system
    ../../Source/Platform/RT105x/system/src/: delay.c lpuart.c sys.c
  group Utilities
    ../../Source/Utilities/: fsl_assert.c fsl_debug_console.c fsl_notifier.c fsl_shell.c
    ../../Source/Utilities/log/: fsl_log.c
    ../../Source/Utilities/io/: fsl_io.c
    ../../Source/Utilities/str/: fsl_str.c
target SmartController_sdram_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: SmartController +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B,DEBUG_IN_SDRAM
  c misc: as above
  c include: as above
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\..\Source\Platform\RT105x\script\rt1052_sdram_scf.scf
target SmartController_flash_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: SmartController +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B
  c misc: as above
  c include: as above
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\..\Source\Platform\RT105x\script\rt1052_flexspi_scf.scf
target SmartController_flash_release (ARM-ADS)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: SmartController
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT6: ROM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
